# Keil uVision project esem16_sdk.uvproj, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ESEM16 ES
  cpu: IRAM(0x20000000-0x200007FF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: esem16_sdk +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\User\inc;..\User;..\CMSIS
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ../User/: main.c common.c intrrupt.c task.c includes.h typedef.h macrodef.h variable.h
    ../User/src/: init.c emu.c iicm.c uart.c
    ../User/inc/: uart.h
  group StartUp
    ./: startup_ESEM16.s
